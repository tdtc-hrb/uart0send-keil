# Keil uVision project uart0send.uvproj, settings and files
target DebugInFlash (ARM-ADS)
  device: LPC1752 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: uart0send
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group CMSIS
    ./Source/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    ./Source/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group App
    ./Source/App/: main.c uart.c
  group Read
    ./Source/: readme.txt
